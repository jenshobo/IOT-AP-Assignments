# Keil uVision project Assignment2.uvprojx, settings and files
target Assignment2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: blinky +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\ST\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./src/: main.c stm32f0xx_it.c
    ./src/lib/USART/: USART.h USART.c
    ./src/lib/queue/: queue.h queue.c
    ./src/lib/led_matrix/: led_matrix.h led_matrix.c
    ./src/lib/delay/: delay.c delay.h
  group startup
    ./startup/: startup_stm32f0xx.s system_stm32f0xx.c
