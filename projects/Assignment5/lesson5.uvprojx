# Keil uVision project lesson5.uvprojx, settings and files
target Assignment5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: lesson5 +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX
  c include: .\inc;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\ST\STM32F0xx\Include;..\..\libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\utilities\STM32F0-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./src/: main6.c stm32f0xx_it.c
    ./src/lib/state/: state.c
  group tim_interrupt
    ./src/lib/tim_it/: tim_it.c
  group pwm
    ./src/lib/pwm/: pwm.c
  group dac
    ./src/lib/dac/: dac.c
  group adc
    ./src/lib/adc/: adc.c
  group stm32f0-discovery
    ../../utilities/STM32F0-Discovery/: stm32f0_discovery.c
  group stm32f0-stdperiphlib
    ../../libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dac.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group startup
    ./startup/: system_stm32f0xx.c startup_stm32f0xx.s
  group data
    ./data/: sound_data.h
