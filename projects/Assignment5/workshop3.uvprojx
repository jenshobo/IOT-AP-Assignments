# Keil uVision project workshop3.uvprojx, settings and files
target Assigment5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: lesson4 +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX
  c include: .\inc;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\ST\STM32F0xx\Include;..\..\libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\utilities\STM32F0-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./src/: stm32f0xx_it.c main.c
  group pwm
    ./src/lib/pwm/: pwm.c pwm.h
  group dac
    ./src/lib/dac/: dac.c dac.h
  group stm32f0-discovery
    ../../utilities/STM32F0-Discovery/: stm32f0_discovery.c
  group stm32f0-stdperiphlib
    ../../libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_spi.c
  group startup
    ./startup/: startup_stm32f0xx.s system_stm32f0xx.c
  group TM1638
    ./src/: stm32_ub_spi2_hd.c stm32_ub_tm1638.c
  group data
    ./data/: sound_data.h
